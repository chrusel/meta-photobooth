FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES_append_rpi = " file://psplash-raspberrypi-img.h;outsuffix=photobooth"
ALTERNATIVE_PRIORITY_psplash-photobooth[psplash] = "50"
