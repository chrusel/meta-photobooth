FEATURE_PACKAGES_photobooth-base = "\
  gphoto2 \
  libgphoto2 \
"
